# Keil uVision project BH-STM32.uvprojx, settings and files
target dht11 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 智能家居 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h codetab.h OLED.c OLED.h floatTOs.c floatTOs.h math_display.c math_display.h smoke.c smoke.h Infrare.c Infrare.h all_init.c all_init.h bsp_beep.c bsp_beep.h
    ../../User/dht11/: bsp_dht11.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/cJSON/: cJSON.c cJSON.h
    ../../User/LED/: LED.c LED.h
    ../../User/millis/: millis.c millis.h
    ../../User/usart3/: usart3.c usart3.h
    ../../User/yun/: yun.c yun.h
    ../../User/stepmotor/: stepmotor.c stepmotor.h
  group DOC
    ../../Doc/: readme.txt
